require optee-os-fio.inc

PV = "3.17.0+git"
SRCREV = "ce9ba515373006adcc55e897fc0d51eaab6ebd6f"
SRCBRANCH = "3.17+fio"
